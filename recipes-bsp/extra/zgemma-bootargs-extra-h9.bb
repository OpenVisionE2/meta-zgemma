require zgemma-bootargs-extra.inc

COMPATIBLE_MACHINE = "^(h9)$"
